<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\passport.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\firmware_platform.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hardware_platform.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>hardware_platform</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>firmware_platform</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freertos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>multiboxes</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>hardware_platform</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>firmware_platform</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>freertos</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>multiboxes</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


