# IAR project multiboxes.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M2S005 Microsemi M2S005
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MICROSEMI_STDIO_THRU_MMUART0; IC61S_4M; IC61S; USB_BAREMETAL
  ICCARM.CCIncludePath2: ../../hw_platform; ../../hw_platform/hal; ../../hw_platform/hal/CortexM3; ../../hw_platform/hal/CortexM3/EWARM; ../../hw_platform/CMSIS; ../../hw_platform/CMSIS/startup_iar; ../../hw_platform/drivers/mss_gpio; ../../hw_platform/drivers/mss_hpdma; ../../hw_platform/drivers/mss_i2c; ../../hw_platform/drivers/mss_nvm; ../../hw_platform/drivers/mss_pdma; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_spi; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_sys_services; ../../hw_platform/drivers/mss_timer; ../../hw_platform/drivers/mss_uart; ../../hw_platform/drivers/mss_usb; ../../hw_platform/drivers/mss_watchdog; ../../hw_platform/drivers/CoreGPIO; ../../hw_platform/drivers/CorePWM; ../../hw_platform/drivers_config/sys_config; ../../include; ../../fw_platform; ../../fw_platform/fpga; ../../fw_platform/motor; ../../fw_platform/nvram; ../../fw_platform/sensor; ../../fw_platform/scanunit; ../../fw_platform/mechanism; ../../fw_platform/gpiokey; ../../FreeRTOS/include; ../../FreeRTOS/portable/IAR/ARM_CM3; ../../config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: multiboxes.bin
  ILINK.IlinkOutputFile: multiboxes.out
  ILINK.IlinkIcfFile: smartfusion2_envm.icf
  ILINK.IlinkAdditionalLibs: Debug\Exe\hardware_platform.a; Debug\Exe\firmware_platform.a; Debug\Exe\freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MICROSEMI_STDIO_THRU_MMUART0; IC61S_4M; IC61S; USB_BAREMETAL
  ICCARM.CCIncludePath2: ../../hw_platform; ../../hw_platform/hal; ../../hw_platform/hal/CortexM3; ../../hw_platform/hal/CortexM3/EWARM; ../../hw_platform/CMSIS; ../../hw_platform/CMSIS/startup_iar; ../../hw_platform/drivers/mss_gpio; ../../hw_platform/drivers/mss_hpdma; ../../hw_platform/drivers/mss_i2c; ../../hw_platform/drivers/mss_nvm; ../../hw_platform/drivers/mss_pdma; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_spi; ../../hw_platform/drivers/mss_rtc; ../../hw_platform/drivers/mss_sys_services; ../../hw_platform/drivers/mss_timer; ../../hw_platform/drivers/mss_uart; ../../hw_platform/drivers/mss_usb; ../../hw_platform/drivers/mss_watchdog; ../../hw_platform/drivers/CoreGPIO; ../../hw_platform/drivers/CorePWM; ../../hw_platform/drivers_config/sys_config; ../../include; ../../fw_platform; ../../fw_platform/fpga; ../../fw_platform/motor; ../../fw_platform/nvram; ../../fw_platform/sensor; ../../fw_platform/scanunit; ../../fw_platform/gpiokey; ../../fw_platform/mechanism; ../../FreeRTOS/include; ../../FreeRTOS/portable/IAR/ARM_CM3; ../../config
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: cardscanner_IC61S_4M.bin
  ILINK.IlinkOutputFile: cardscanner_IC61S_4M.out
  ILINK.IlinkIcfFile: smartfusion2_envm - release.icf
  ILINK.IlinkAdditionalLibs: Release\Exe\hardware_platform.a; Release\Exe\firmware_platform.a; Release\Exe\freertos.a
  group application
    ../../application/: console.c ddr_test.c indicator.c indicator.h nvmdata.c nvmdata.h nvram_test.c tasks.c tasksync.h test.c
  group config
    ../../config/: board_config.c interrupts.c mechdev.h ramp_IC61S_4M.c
  group conio
    ../../../../platform/hw_platform/CMSIS/startup_iar/: read.c write.c
